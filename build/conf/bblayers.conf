## build/conf/bblayers.conf
```bitbake
BBPATH := "${TOPDIR}"

BBLAYERS = "\
    ${TOPDIR}/../poky/meta \
    ${TOPDIR}/../poky/meta-poky \
    ${TOPDIR}/../meta-training-examples \
    "
    
```
